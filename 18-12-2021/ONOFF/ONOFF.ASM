;1)Write a Assembly Program for On Off Toggling?

#include<p16f877a.inc>
ORG 00H
BSF STATUS,RP0
BCF STATUS,RP1
MOVLW 0X00
MOVWF TRISB
BCF STATUS,RP0
MOVLW 0X01
MOVWF PORTB

MOVLW 0XFF
MOVWF 0X41

CALL GOWTHAM
CALL GOWTHAM1
GOTO END_1
END_1
		GOWTHAM:
			MOVLW 0XFF 		;200 count
			MOVWF 0X21
			MOVWF 0X31
			DECFSZ 0X41,1
			GOTO ON
			RETURN
		ON		
			MOVLW 0X01
			MOVWF PORTB
			DECFSZ 0X21,1
			GOTO ON
			GOTO OFF
		OFF
			CLRF PORTB
			DECFSZ 0X31,1
			GOTO OFF
			GOTO GOWTHAM
			RETURN		
		GOWTHAM1:
				MOVLW 0XF5
				MOVWF 0X41
				GOTO GOWTHAM
				RETURN
NOP
END





			

