#INCLUDE<p16f877a.inc>
ORG 00H
MOVLW B'00000011
MOVWF 0X31
MOVLW B'00000010
MOVWF 0X21
MOVWF 0X42
MOVWF 0X43
MOVLW B'00000010
MOVWF 0X51
CALL SUBROUTINE
CALL GOWTHAM1
END_1
NOP
		SUBROUTINE:
					GOWTHAM
							RLF 0X42
							RLF 0X42
							MOVF 0X42,0
							MOVWF 0X21
							DECFSZ 0X31,1
							GOTO GOWTHAM
							RETURN
		GOWTHAM1
					MOVF 0X43,0
					MOVWF 0X42
					MOVWF 0X21
				GOWTHAM2
					RLF 0X42
					RLF 0X42
					MOVF 0X42,0
					MOVWF 0X21
					DECFSZ 0X51,1
					GOTO GOWTHAM2	
					RETURN

NOP
END

							
							