#include<p16f877a.inc>
ORG 00H
BSF STATUS,RP0
BCF STATUS,RP1
MOVLW 0X00
MOVWF TRISB
BCF STATUS,RP0
MOVLW 0X01
MOVWF PORTB
MOVLW B'00000001
MOVWF 0X21
MOVLW 0XC8
MOVWF 0X22
MOVWF 0X23
MOVWF 0X24
CALL GOWTHAM
GOTO END_1
END_1
NOP
			GOWTHAM:
				MOVLW 0XC8
				MOVWF 0X22
				MOVWF 0X23
				DECFSZ 0X24,1
				MOVF 0X21,0
				RETURN
			 ON
				MOVWF PORTB
				DECFSZ 0X22,1
				GOTO ON
				MOVF PORTB,0
				GOTO OFF
			OFF
				CLRF PORTB
				DECFSZ 0X23,1
				GOTO OFF
				RLF 0X21,1
				RLF 0X21,1
				GOTO GOWTHAM
END