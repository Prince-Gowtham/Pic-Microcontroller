#include<p16f877a.inc>
ORG 00H
MOVLW B'00000001
MOVWF 0X21
MOVLW B'10000000
MOVWF 0X22
MOVLW B'00001010
MOVWF 0X23
CALL SUBROUTINE
GOTO SUBROUTINE1
GOTO END_1
NOP
SUBROUTINE:
	GOWTHAM 
		RLF 0X21,1
		DECFSZ 0X23,1
		GOTO GOWTHAM
		ADDWF 0X23,1
		RETURN
SUBROUTINE1:  
	GOWTHAM1
		RRF 0X22,1
		DECFSZ 0X23,1
		GOTO GOWTHAM1
		NOP
		RETURN
END_1
END